<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Oct 22 15:07:41 2024</timestamp>
			<uuid>{1885a072-9208-4f84-83d5-6f1f747f06bb}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/viterbi/09/xibeijia/work_gpdk045/lab3/MUX_2to1___2X/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/viterbi/09/xibeijia/work_gpdk045/lab3/MUX_2to1___2X/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/viterbi/09/xibeijia/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/viterbi/09/xibeijia/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
