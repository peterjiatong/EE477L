<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Oct 16 18:07:16 2024</timestamp>
			<uuid>{91d5506f-3b08-441c-9929-b6cac3a62966}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/viterbi/08/ziqingla/work_gpdk045/project_demo/XOR/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/viterbi/08/ziqingla/work_gpdk045/project_demo/XOR/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/viterbi/08/ziqingla/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/viterbi/08/ziqingla/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
